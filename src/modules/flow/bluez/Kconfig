## src/modules/flow/bluez/Kconfig
```kconfig
config FLOW_NODE_TYPE_BLUEZ
	tristate "Node type: bluez"
	depends on SOL_BUS
	default m
```
